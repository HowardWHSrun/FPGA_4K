# Repository HowardWHSrun/FPGA_4K

File README.md (part):

# FPGA_4K

**Current overview · 5 November 2026:** [System overview V27](index.html) is one page with the board names, the two approaches in 3D, printable models and downloads: Frontend FPGA Board V37, HDMI Extension Board V37, ASIC board PCB-5 and Direct LDO Carrier V6 (sent to fab). It follows the [4 November presentation](presentation/meetings/2026-11-04-v16/). The [previous overview V25](overview-2026-11-02-v25.html) is preserved.

## Earlier dated records

These entries describe earlier deliveries. Current boards and downloads are in the overview linked above.

**Board pages · 2 November 2026:** [Frontend FPGA Board V6](frontend/) · [HDMI Extension Board V21](xem8310/) · [Direct LDO Carrier V6](direct-ldo/). Each page includes a full editable KiCad ZIP with schematic, PCB, settings, rules, local libraries and available 3D models. These revisions are superseded except Direct LDO Carrier V6.

**[HDMI Extension Board · earlier V5 schematic / V3 placement · 1 November 2026](xem8310/)** — one-page PDF and SVG, six-layer placement, interactive 3D, component search and [editable KiCad downloads](xem8310/#files). Four new test points await PCB placement; routing and hardware qualification remain open.

**[Direct LDO Carrier V6 · 31 October](presentation/overview/carrier-v6/)** — MC2 pin 14 VREFP now joins pin 16 GNDADC. Current native layout/schematic and matching [V6 KiCad, Gerbers, BOM and CPL](hardware/xem8305-carrier/dated/2026-10-31/carrier-v6/README.md); same 80 fitted parts / 42 BOM groups. Native checks pass; JLC placement, factory acceptance and powered qualification remain pending.

**[Preserved Direct LDO Carrier V4 / BOM V5 · 31 October](presentation/overview/carrier-v4/)** — earlier native layout and schematic, with preserved [KiCad and JLCPCB files](hardware/xem8305-carrier/dated/2026-10-31/carrier-v4-bom-v5/README.md). 80 fitted parts in 42 BOM groups; fresh native checks clear. Matched-part placement and factory acceptance remain pending.

**[Preserved Direct LDO Carrier V3 · 30 October](presentation/overview/carrier-v3/)** — earlier native viewers and [V3 files](hardware/xem8305-carrier/dated/2026-10-30/carrier-v3/README.md). Use the V6 package above for current review.

**[28 October weekly FPGA presentation · V8](presentation/meetings/2026-10-28-v8/)** — six interactive slides with the eight-stack system assembly, XEM8310/custom breakout and PCIe-to-PC path, HDMI schematic discussion, and XEM8305/LDO carrier views. Native interactive PCB layouts support layers, planes, part inspection and net highlighting. Shared comments accept a name or Anonymous beside Notes and Fullscreen. The breakout and interface remain under review. [Scope and sources](presentation/meetings/2026-10-28-v8/README.md).

**[Whole alternative assembly · Overview V25](index.html?approach=direct#overview)** — rotate the XEM8305, current Carrier V1 and original LDO together. Use Seated, illustration spacing and individual board focus to inspect their connector alignment. Fresh registration matches the current carrier; the LDO extends about 17.2 mm beyond its edge. Carrier 80/80 native body-model verification remains scoped to the carrier. [Assembly sources and nominal fit](hardware/xem8305-carrier/dated/2026-10-26/assembly-v2/README.md). 26 October 2026.

**[Carrier V1 alone · 26 October 2026](presentation/overview/carrier-v1/)** — current four-layer XEM8305 / existing-LDO carrier, with 3D, layout and schematic views. **All 80 component bodies verified in native 3D**; saved-rule DRC, opens and schematic/PCB parity are 0 / 0 / 0. [Review files and verification scope](hardware/xem8305-carrier/dated/2026-10-26/carrier-v1/README.md). Purchasing, powered operation, toleranced assembly and fabrication qualification remain open.

**[Preserved HDMI Extension Board · V10](xem8310-v10/)** — cleaner standalone review with matching PCB, interactive 3D, one-page schematic and 351-component browser. Eight HDMI ports, six layers and shared power/JTAG. Placement only: 776 unrouted connections; routing and DRC cleanup remain open. [Earlier V9 schematic review](xem8310-v9/) · [V8 placement](xem8310-v8/). 25 October 2026.

**[XEM8310 eight-port carrier · V8](xem8310-v8/)** — standalone schematic, interactive PCB/3D, 422-component browser and native review files. V7 electrical design / six-layer V8 rough placement, 25 October 2026. Routing and hardware qualification remain open.

**[21 October FPGA hardware presentation · V2](presentation/meetings/2026-10-21-v2/index.html)** — LDO carrier readiness and JLC sourcing, full assembly animation, interposer V20 schematic/layout/3D, separate FPGA/LDO boards and FPGA V60 updates. Nine interactive slides; review and powered qualification remain open.

**[Custom FPGA assembly sequence · V23 · 20 October 2026](index.html?approach=custom#overview)** — one timeline joins ASIC concepts / LDO V13 / FPGA V54, then the saved interposer V12 / BRK / XEM stack; sheep context is optional. The page matches the overview layout and uses detailed project meshes with nominal public connector previews. [Model scope and credits](presentation/overview/assembly-v23/model-sources.html).

[Preserved carrier V42 overview](overview-2026-10-20-v23.html?approach=direct#overview) retains the earlier XEM8305–carrier–LDO assembly and illustration-spacing control. The updated alternative above uses the separate Carrier_V1 from-scratch design; the earlier V42 and custom FPGA records retain their own scope.

**[Preserved XEM8305 carrier review · V42 · 18 October 2026](hardware/xem8305-carrier/dated/2026-10-18/v42/README.md)** — D601 moved to the visible underside; unrelated routing and component positions are preserved. Editable KiCad project, PDF, six-layer plots, matching BOM/CPL and manufacturing review files are included. Native physical/silk/open/parity checks pass; sourcing, factory and powered qualification remain open. This carrier is separate from the standalone FPGA V41 and is not a fabrication release.

[Preserved carrier V41 review](hardware/xem8305-carrier/dated/2026-10-18/v41/README.md) retains its earlier source, files and checks.

- [V32 carrier power-routing lesson · 17 October](presentation/learn/v32-power/): actual KiCad copper, clickable parts, supply/return diagrams and a proposed fix sequence. Read-only V32; no fabrication qualification.

[Two parallel approaches](index.html#overview): custom FPGA with new LDO electronics, and a separate XEM8305 carrier directly connecting the existing LDO board. Choose A or B to show only that approach’s path, overview and board navigation. One Updates button collects announcements; the original viewer/story structure adapts to desktop and mobile screens. [Overview revision guide](presentation/overview/README.md).

**[Current hardware overview · updated 15 October 2026 · V8](index.html)** — current boards together in interactive 3D: four ASIC PCB-5 references, FPGA V41 + LDO V5 or combined V7, and the separate BRK8305 / interposer V4 / XEM8305 stack connected by micro-HDMI cable. Full host geometry and native interposer pad, silkscreen and soldermask detail replace the simplified preview; **Interposer** focus exposes its top and bottom. Part descriptions use board revisions without individual assignments. The parallel direct-LDO route uses carrier V17. The original page structure, current native downloads and earlier dated records are preserved.

**[14 October presentation · carrier, FPGA and LDO](presentation/meetings/2026-10-14-v17/index.html)** — eight pages with interactive 3D, native layouts and complete schematics.

**Preserved LDO carrier · V15 · published 12 October:** [XEM–carrier–LDO assembly, six-layer routing and files](presentation/xem/carrier-r15-2026-10-12.html). The [overview carrier selection](./#receiver) now opens V17. Main power copper is wider; the XEM and Gerald LDO attachment uses simplified source geometry with nominal 5 mm and 2 mm mating gaps. Complete editable KiCad project and R14-to-R15 PDF included. Routing review; hardware qualification remains open.

**Earlier LDO carrier files · C4.8-R5 · 9 October:** [KiCad project, Gerbers, drills and routing views](presentation/downloads/#carrier-c4-8-r5). Four layers, 53 × 83 mm, aligned corner vias. Saved-board DRC, opens and schematic/PCB parity are zero; inherited schematic ERC cleanup and hardware qualification remain open. Review files; not a fabrication release.

**Weekly meeting · 7 October:** [FPGA PCB and LDO presentation](presentation/meetings/2026-10-07.html) · [PowerPoint, PDF and complete KiCad projects](presentation/meetings/2026-10-07.html#files). Opens with the XEM8305/carrier/LDO assembly and J1/J19 views, followed by Zitong’s original component list and current PCB layouts. Connector seating and hardware qualification remain open.

**Preserved direct carrier · 5 October:** [XEM8305 R3 files and review](presentation/xem/direct-all-connectors-2026-10-05.html) · [all files, Gerbers, KiCad and eight-sheet schematic](presentation/downloads/#xem8305-direct-r3). One six-layer carrier, all 260 XEM contacts accounted for. Native/ERC/DRC/opens/parity and actual CAM checks pass. Factory approval, assembly sourcing/placement/process and first-board fit/power/ASIC tests remain pending. [Earlier R2](presentation/xem/direct-r2-2026-10-05.html) is preserved.

**Preserved cabled backup review · 2 October:** [Small routing board 3D](presentation/ldo-backup/?view=routing) · [connection to the existing LDO](presentation/ldo-backup/?view=connection). XEM8305 connects by cable. The 18 × 25 mm preview is provisional; the shared SpikeGadgets board dimensions and cable connector/pinout remain unverified. This cabled study retains its original date and limits; the current direct R3 project is linked above.

**Earlier meeting — 2 October 2026:** [One-chip backup first and main FPGA review](presentation/meetings/2026-10-02.html). Reuse Gerald's existing LDO board and confirmed J1/J19 connectors through a rigid adapter to XEM8305; review V11 and the 35T candidate in parallel. Exact parts, carrier power, mating and firmware remain open. This dated record updates the working sequence; older architecture descriptions below remain historical context.

[Wednesday’s presentation](presentation/meetings/2026-09-30.html) · [R12 simple connection overview](presentation/schematic/simple.html) · [current native 3D](presentation/adapter/assembly.html?revision=r12) · [editable R12 package and audit](hardware/xem8310-adapter/dated/2026-09-29/r12-single-link/README.md). Current focus is one 19-contact link. All 19 contacts are mapped in a 10-sheet schematic with ERC 0; the PCB is still in progress: 10/19 contacts reach all intended copper endpoints, with 9 open connections and 11 dangling warnings. R8/R9/R10 three-port studies remain preserved. No fabrication release.

<!-- CURRENT_FPGA_LEARNING_REPORT -->
**Preserved micro-HDMI learning report:** [PDF · 45 pages](hardware/fpga-interface-study/dated/2026-09-27/completion-report/FPGA100T_Current_Learning_Review.pdf) · [editable LaTeX](hardware/fpga-interface-study/dated/2026-09-27/completion-report/FPGA100T_Current_Learning_Review.tex). Explains the earlier 125-component / 752-endpoint checkpoint. It does not cover the USB-C additions.
<!-- /CURRENT_FPGA_LEARNING_REPORT -->

**Earlier learning report:** [Visual explanations and professor briefing · 33-page PDF](hardware/fpga-interface-study/dated/2026-09-26/learning-report/FPGA100T_Learning_And_Professor_Review.pdf). Explains the earlier snapshot; use the current native audit and pin map for the updated design.

**Earlier micro-HDMI component and pin review:** [Earlier presentation](presentation/fpga/micro-hdmi.html#architecture) · [labeled pin map](presentation/fpga/pins/) · [presenter notes](presentation/fpga/data/Presenter_Notes.md). 116 candidate digital ASIC nets have native assignments plus one external analog reservation; 83 pins are intentionally unused and 19 endpoints reserve future interfaces. Six former NC pins are assigned GND. The pin map separates assignments from current copper status.

Shared PCB development for the 4K neural-recording system: working designs, interface decisions, reference boards and acquisition software.

**Selected custom FPGA — XC7A25T-2CSG325I:** [Current board section and native-derived 3D placement](presentation/fpga/current-25t.html). Three separate boards and three cables are proposed. The 25T PCB is unrouted and its inherited rigid DF40 interface is under redesign. The [28 September 50T placement and parts review](presentation/fpga/index.html) remains available as a historical checkpoint; its 48-line purchasing draft is not a 25T order list. **No board is released for fabrication or purchase.**

**Preserved three-port receiver architecture — 29 September:** [Adapter overview, exact pin map and interactive 3D](presentation/adapter/) · [R7 five-page KiCad schematic](hardware/xem8310-adapter/dated/2026-09-29/r7-three-port/BRK8310_Three_Port_Adapter_R7_Candidate.pdf) · [editable R7 project](hardware/xem8310-adapter/dated/2026-09-29/r7-three-port/BRK8310_Three_Port_Adapter_R7_KiCad_Project.zip). XEM8310 currently sits directly on BRK8310. The proposed interposer would fit between them and connect three custom FPGA cables to MC3 GTY banks 226, 225 and 224 simultaneously. Matching BRK GTY contacts would be isolated; BRK J6 PCIe is unavailable during three-link acquisition and is only an alternate future mode. The optional R10 HDI study connects all 12 selected signal pairs, with97 items still open; R9 and R8 remain preserved. The three protected 12 V cable branches, physical fit, clock/link, USB capture and programming remain unresolved. Earlier [one-port R3/R4](hardware/xem8310-adapter/dated/2026-09-29/r3-interposer-candidate/README.md) and [direct-XEM R2](hardware/xem8310-adapter/dated/2026-09-29/r2-12v/README.md) remain separate history.

**Earlier FPGA revisions:** [28 September unrouted 50T placement and parts](presentation/fpga/index.html), [preserved routed 100T micro-HDMI checkpoint](presentation/fpga/micro-hdmi.html) and [USB-C development revision](presentation/fpga/usb-c.html) remain separate historical studies. The [28 September 5 V contact proposal](presentation/fpga/micro-hdmi-19.html) is dated history; the [current three-port adapter page](presentation/adapter/) shows the proposed 12 V contact and selected 25T link allocation.

## Start working with the team

**[Team start page](docs/team/README.md)** · **[Setup and daily workflow](CONTRIBUTING.md)** · **[Owners and open work](docs/team/owners-and-work.md)**

| Work | Start here | Status |
|---|---|---|
| Selected custom FPGA | [Open the 25T board section](presentation/fpga/current-25t.html) | Three identical board links proposed; PCB unrouted; DF40 interface under redesign |
| Current single-link interposer | [R12 schematic, native 3D and editable project](hardware/xem8310-adapter/dated/2026-09-29/r12-single-link/README.md) | Schematic implemented; routing in progress; one 19-contact link |
| Preserved three-port receiver adapter | [Open the schematic, pin map and 3D](presentation/adapter/) | Logical schematic browsable; R10 all 12 pair endpoints connected under provisional HDI rules;97 opens; power/JTAG unfinished |
| Earlier 50T placement | [Open the 28 September board and parts review](presentation/fpga/index.html) | Historical 50T candidate; not the current selected device or BOM |
| Preserved routed 100T | [Open the earlier micro-HDMI checkpoint](presentation/fpga/micro-hdmi.html) | 125 placed parts; separate routing and population evidence |
| Separate USB-C revision | [Open the development board](presentation/fpga/usb-c.html) | 116 provisional FPGA signals + one analog reservation; unfinished routing; **not for manufacture** |
| Earlier FPGA team draft | [September 21 import](hardware/fpga-board/README.md) | Preserved earlier electrical draft; superseded device/interface choices; **not for manufacture** |
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
## KiCad design hardware/hdmi-extension-board/dated/2026-11-02/v21/project/records/as-saved/HDMI_Extension_Board_Study_V21.kicad_pcb

File hardware/hdmi-extension-board/dated/2026-11-02/v21/project/README.md:

# HDMI Extension Board V21

Published snapshot: 2 November 2026. Open `HDMI_Extension_Board_Study_V21.kicad_pro` in KiCad 10.0.6 or newer after extracting the whole folder. Keep libraries and models beside the project.

This package contains the current six-layer HDMI Extension Board, eight Micro-HDMI links with switched 5 V feeds, USB-C JTAG, and the XEM8310 PCIe interface. It includes the complete editable project and existing JLC Gerbers, BOM, CPL and order note. Signal integrity, ESD, thermal behavior, bracket fit, factory acceptance and powered qualification remain open. V21 has not had an independent electrical/layout review.

## Check results and packaging

- Packaged PCB, saved and reloaded: **0 DRC errors, 1 footprint-library warning, 0 open connections, 0 schematic/PCB parity findings**.
- Schematic: **0 ERC errors, 190 isolated-pin-label warnings**. No ignored categories or DRC exclusions.
- The original saved PCB had **164 DRC errors from stale zone-fill geometry**. Refilling clears these. The portable PCB includes regenerated fills; original main files are preserved under `records/as-saved/` as evidence. Use the root project for editing.
- Structural comparison confirms unchanged routing, footprint/pad geometry, nets, rules and zone boundaries after excluding cached fills, model paths and generator version. Model paths were made portable; active local source files were not changed.
- 267 schematic components, 282 PCB footprints, 4,611 track/via objects, 17 copper zones. JLC BOM: 238 fitted references in 63 groups; CPL contains the same 238 references.
- Every model referenced by the active PCB is available. Retained historical footprint-library entries contain 60 unresolved model references (38 distinct paths); these do not prevent displaying the active PCB. See `records/packaging-adaptations.json`. Nominal and substitute models do not establish physical fit.

## JLC files and known limits

[JLC order note](JLC_Order/ORDER_NOTE_FOR_JLC.md) · [Gerbers and drills](JLC_Order/HDMI_Extension_Board_V21_Gerbers.zip) · [BOM](JLC_Order/HDMI_Extension_Board_V21_BOM.csv) · [CPL](JLC_Order/HDMI_Extension_Board_V21_CPL.csv)

These order files are unchanged copies from the current folder; their ZIP integrity and BOM/CPL reference consistency were checked. This publication does not establish CAM equivalence, factory acceptance, placement approval or an order. The original order settings are retained in `records/START_HERE_as_saved.txt`.

The source documentation flags J4's 5 A rating versus the 6.3 A worst-case estimate, no input fuse/reverse-polarity protection, untested x8-or-larger slot/custom-bracket fit, and incompatibility with the older 3.3 V Frontend V4. Resolve these through the recorded reviews and physical tests.

## Sources

Source folder: `HDMI_Extension_Board_From_Scratch_V1`. Native filenames and library identities are preserved. `package-manifest.json` records original hashes, packaged hashes and adaptations. Source PCB SHA-256: `8ff7cc2fdc1c479b25f2f646e52ac867289ffdf3f1772307dc79cdd43fffe3c5`. Source schematic SHA-256: `6542532a85e274cc83eeaf0e4385a54eac447f99c28cb9b57f32c31b8596b803`.

The design derives from the Opal Kelly BRK8310 and project-authored changes; engineering citations remain on the schematic. Existing third-party library/model terms continue to apply; this publication grants no new rights. [KiCad library license](https://www.kicad.org/libraries/license/).

Schematic: HDMI_Extension_Board_Study_V21.kicad_sch, HDMI Extension Board - XEM8310 and USB-C JTAG

Parts:
C5: EEE-FK1E221P; BRK_C5; VOLTAGE 25V; PARTNUMBER 001532
C6: TMK105BJ104KV-F; BRK_C6; TOLERANCE (%) 10; VOLTAGE 25V; MANUFACTURER_PN TMK105BJ104KV-F
C7: C0402C104K8PACTU; BRK8310_C7; PARTNUMBER 000070
C8: C0402C104K8PACTU; BRK8310_C8; PARTNUMBER 000070
C9: C0402C104K8PACTU; BRK8310_C9; PARTNUMBER 000070
C10: C0402C104K8PACTU; BRK8310_C10; PARTNUMBER 000070
C11: C0402C104K8PACTU; BRK8310_C11; PARTNUMBER 000070
C12: C0402C104K8PACTU; BRK8310_C12; PARTNUMBER 000070
C13: C0402C104K8PACTU; BRK8310_C13; PARTNUMBER 000070
C14: C0402C104K8PACTU; BRK8310_C14; PARTNUMBER 000070
C15: C0402C104K8PACTU; BRK8310_C15; PARTNUMBER 000070
C16: C0402C104K8PACTU; BRK8310_C16; PARTNUMBER 000070
C17: C0402C104K8PACTU; BRK8310_C17; PARTNUMBER 000070
C18: C0402C104K8PACTU; BRK8310_C18; PARTNUMBER 000070
C19: C0402C104K8PACTU; BRK8310_C19; PARTNUMBER 000070
C20: C0402C104K8PACTU; BRK8310_C20; PARTNUMBER 000070
C27: C0402C104K8PACTU; BRK8310_C27; PARTNUMBER 000070
C28: C0402C104K8PACTU; BRK8310_C28; PARTNUMBER 000070
C31: C0402C104K8PACTU; BRK8310_C31; PARTNUMBER 000070
C32: C0402C104K8PACTU; BRK8310_C32; PARTNUMBER 000070
C500: 4.7u; C500; Voltage 10V; MPN CL05A475MP5NRNC; JLCPCB C23733
C501: 100n; C501; Voltage 10V; MPN C0402C104K8PACTU; JLCPCB C2649544
C502: 100n; C502; MPN C0402C104K8PACTU; JLCPCB C2649544
C503: 18p; C503; MPN C0402C180J5GACTU; JLCPCB C22442494
C504: 18p; C504; MPN C0402C180J5GACTU; JLCPCB C22442494
C505: 100n; C505; MPN C0402C104K8PACTU; JLCPCB C2649544
C506: 100n; C506; Voltage 16V; Tolerance 10%; MPN CL05B104KO5NNNC; JLCPCB C1525
C507: 4.7u; C507; Voltage 6.3V; Tolerance 20%; MPN JMK105BBJ475MV-F; JLCPCB C87147
C508: 100n; C508; Voltage 10V; Tolerance 10%; MPN C0402C104K8PACTU; JLCPCB C2649544
C509: 100n; C509; Voltage 10V; Tolerance 10%; MPN C0402C104K8PACTU; JLCPCB C2649544
C510: 100n; C510; Voltage 10V; Tolerance 10%; MPN C0402C104K8PACTU; JLCPCB C2649544
C511: 100n; C511; Voltage 10V; Tolerance 10%; MPN C0402C104K8PACTU; JLCPCB C2649544
C512: 4.7u; C512; Voltage 6.3V; Tolerance 20%; MPN JMK105BBJ475MV-F; JLCPCB C87147
C513: 4.7u; C513; Voltage 6.3V; Tolerance 20%; MPN JMK105BBJ475MV-F; JLCPCB C87147
C514: 100n; C514; Voltage 10V; Tolerance 10%; MPN C0402C104K8PACTU; JLCPCB C2649544
C515: 4.7u; C515; Voltage 6.3V; Tolerance 20%; MPN JMK105BBJ475MV-F; JLCPCB C87147
C516: 100n; C516; Voltage 10V; Tolerance 10%; MPN C0402C104K8PACTU; JLCPCB C2649544
C517: 100n; C517; Voltage 10V; Tolerance 10%; MPN C0402C104K8PACTU; JLCPCB C2649544
C518: 100n; C518; Voltage 10V; Tolerance 10%; MPN C0402C104K8PACTU; JLCPCB C2649544
C519: 10n; C519; Voltage 16V; Tolerance 10%; MPN C0402C103K4RACTU; JLCPCB C2649513
C601, C603: 2.2u; C_0603_1608Metric; JLCPCB C100082
C604, C605, C606, C609, C610, C611, C612, C613, C614, C615, C616, C617, C618: 100n; C_0603_1608Metric; JLCPCB C14663
C608: 1n; C_0603_1608Metric; JLCPCB C8808
C700, C701, C702, C703: 10uF; C_1210_3225Metric; Manufacturer_PN GRM32ER71H106KA12L; JLCPCB C77102
C704, C705, C706, C707: 47uF; C_1210_3225Metric; Manufacturer_PN GRM32ER61C476KE15L; JLCPCB C77101
C708: 22pF; C_0603_1608Metric; Manufacturer_PN TCC0603COG220J500CT; JLCPCB C376775
C711, C712, C713, C714, C715, C716, C717, C718: 100nF; C_0603_1608Metric; Manufacturer_PN CC0603KRX7R9BB104; JLCPCB C14663
D500: USBLC6-2SC6; D500; Manufacturer_PN USBLC6-2SC6; JLCPCB C7519
D701, D702, D703, D704, D705, D706, D707, D708: RED; LED_0603_1608Metric; Manufacturer_PN LTST-C190KRKT; JLCPCB C94869
FB500: 600R; FB500; MPN BLM18AG601SN1D; JLCPCB C19330
FB501: 600R; FB501; MPN BLM18AG601SN1D; JLCPCB C19330
FB502: 600R; FB502; MPN BLM18AG601SN1D; JLCPCB C19330
FB503: 220R @100MHz; FB503; MANUFACTURER_PN BLM21PG221SN1D; JLCPCB C85840
J4: PJ-102AH; BRK_J4; MANUFACTURER_PN PJ-102AH
J6: PCIe x8 Card-Edge Connector; BRK8310_J6
J500: USB4110-GF-A; J500; MANUFACTURER_PN USB4110-GF-A; JLCPCB C5143397
J610, J611, J612, J613, J614, J615, J616, J617: 467651001; HDMI_Micro-D_Molex_46765-1xxx; JLCPCB C563878
MC1: BTE-040-01-F-D-A; BRK_MC1; PARTNUMBER 000059
MC2: BTE-040-01-F-D-A; BRK_MC2; PARTNUMBER 000059
MC3: QTH-040-01-F-D-DP-A; BRK_MC3; PARTNUMBER 002313
MH1: MTG; BRK_MH1
MH2: MTG; BRK_MH2
MH3: MTG; BRK_MH3
MH4: MTG; BRK_MH4
Q1: SI1922EDH-T1-GE3; BRK8310_Q1; PARTNUMBER 002018
R2: CRCW06030000Z0EA; BRK8310_R2; MANUFACTURER_PN CRCW06030000Z0EA
R7: CRCW06030000Z0EA; BRK8310_R7; MANUFACTURER_PN CRCW06030000Z0EA
R9: CRCW06030000Z0EA; BRK8310_R9; MANUFACTURER_PN CRCW06030000Z0EA
R10: CRCW06030000Z0EA; BRK8310_R10; MANUFACTURER_PN CRCW06030000Z0EA
R11: CRCW06030000Z0EA; BRK8310_R11; MANUFACTURER_PN CRCW06030000Z0EA
R13: CRCW0402200KFKED; BRK8310_R13; PARTNUMBER 000964
R14: CRCW04024K75FKED; BRK8310_R14; PARTNUMBER 001008
R15: CRCW04024K75FKED; BRK8310_R15; PARTNUMBER 001008
R18: CRCW0402100KFKED; BRK8310_R18; TOLERANCE (%) 1; PARTNUMBER 001070
R23: CRCW0402200KFKED; BRK8310_R23; PARTNUMBER 000964
R24: CRCW0402100KFKED; BRK8310_R24; TOLERANCE (%) 1; PARTNUMBER 001070
R25: CRCW0402100KFKED; BRK8310_R25; TOLERANCE (%) 1; PARTNUMBER 001070
R28: CRCW04020000Z0ED; BRK8310_R28; PARTNUMBER 000755
R30: CRCW04024K75FKED; BRK8310_R30; PARTNUMBER 001008
R31: CRCW04024K75FKED; BRK8310_R31; PARTNUMBER 001008
R32: CRCW0402100KFKED; BRK8310_R32; TOLERANCE (%) 1; PARTNUMBER 001070
R33: CRCW0402100KFKED; BRK8310_R33; TOLERANCE (%) 1; PARTNUMBER 001070
R500: 5.1k 1%; R500; MPN CRCW04025K10FKEDC; JLCPCB C2076825
R501: 5.1k 1%; R501; MPN CRCW04025K10FKEDC; JLCPCB C2076825
R502: 100k; R502; Tolerance 1%; MPN CRCW0402100KFKED; JLCPCB C481918
R503: 100k; R503; Tolerance 1%; MPN CRCW0402100KFKED; JLCPCB C481918
R504: 2k; R504; Tolerance 1%; MPN CRCW04022K00FKED; JLCPCB C482125
R505: 10k; R505; Tolerance 1%; MPN CRCW040210K0FKED; JLCPCB C71617
R506: 10k; R506; Tolerance 1%; MPN CRCW040210K0FKED; JLCPCB C71617
R507: 12k 1%; R507; Tolerance 1%; MPN CRCW040212K0FKED; JLCPCB C481938
R509: 10k; R509; Manufacturer_PN CRCW040210K0FKED; JLCPCB C71617
R600: 3.3k; R_0603_1608Metric; JLCPCB C22978
R601, R602, R603: 22R; R_0603_1608Metric; JLCPCB C23345
R605: 301k; R_0603_1608Metric; JLCPCB C23026
R606, R608, R616: 100k; R_0603_1608Metric; JLCPCB C25803
R607: 402k; R_0603_1608Metric; JLCPCB C23048
R613: 68k; R_0603_1608Metric; JLCPCB C23231
R614: 4.7k; R_0603_1608Metric; JLCPCB C23162
R615: 12k; R_0603_1608Metric; JLCPCB C22790
R620, R621, R622, R623, R624, R625, R626, R627, R628: 10k; R_0603_1608Metric; JLCPCB C25804
R629: 1k; R_0603_1608Metric; JLCPCB C21190
R640, R641, R642, R643, R644, R645, R646, R647, R648, R649, R650, R651, R652, R653, R654, R655, R656, R657, R658, R659, R660, R661, R662, R663, R664, R665, R666, R667, R668, R669, R670, R671: 100R; R_0603_1608Metric; JLCPCB C22775
R700: 40.2k; R_0603_1608Metric; Manufacturer_PN MCR03EZPFX4022; JLCPCB C308258
R701, R703: 10k; R_0603_1608Metric; Manufacturer_PN RC0603FR-0710KL; JLCPCB C98220
R702: 13k; R_0603_1608Metric; Manufacturer_PN ERJ-H3EF1302V; JLCPCB C4083262
R711, R712, R713, R714, R715, R716, R717, R718: 37.4k; R_0603_1608Metric; Manufacturer_PN RC0603FR-0737K4L; JLCPCB C163425
R721, R722, R723, R724, R725, R726, R727, R728: 3.3k; R_0603_1608Metric; Manufacturer_PN 0603WAF3301T5E; JLCPCB C22978
SW600: SRBQ490100; ALPS_SRBQ490100_1P9T; JLCPCB C370985
SW601: JS202011JCQN; SW700; JLCPCB C221665
TP9: SMDAT_VIO; BRK8310_TP9
TP10: SMDAT_PCIE; BRK8310_TP10
TP11: SMCLK_PCIE; BRK8310_TP11
TP12: SMCLK_VIO; BRK8310_TP12
TP13: PERST_VIO; BRK8310_TP13
TP14: PERST_PCIE; BRK8310_TP14
TP15: WAKE_VIO; BRK8310_TP15
TP16: WAKE_PCIE; BRK8310_TP16
TP20: +12V_PCIE_C; BRK8310_TP20
TP21: FAULT; BRK8310_TP21
TP700, TP701, TP702, TP703, TP704, TP705, TP706, TP707, TP708, TP709: TestPoint; TestPoint_Pad_D1.5mm
TP710: 12V_IN; TestPoint_Pad_D1.5mm
TP711: 1V8_XEM; TestPoint_Pad_D1.5mm
TP712: 3V3_XEM; TestPoint_Pad_D1.5mm
TP713: 3V3_FTDI; TestPoint_Pad_D1.5mm
U2: PCA9306DCUR; BRK8310_U2; PARTNUMBER 001474
U4: SN74AXC1T45DCK; BRK8310_U4; PARTNUMBER 002140
U5: AP22653AW6-7; BRK8310_U5; PARTNUMBER 002224
U6: PCA9306DCUR; BRK8310_U6; PARTNUMBER 001474
U501: FT232HQ-REEL; U501; MANUFACTURER_PN FT232HQ; JLCPCB C82158
U505: 93LC56BT-I/SN; SOIC-8_3.9x4.9mm_P1.27mm; MANUFACTURER_PN 93LC56BT-I/SN; JLCPCB C6164
U602: TXU0304PWR; TSSOP-14_4.4x5mm_P0.65mm; JLCPCB C4364118
U603: TPS3700DDCR; SOT-23-6; JLCPCB C33002
U605: TPS3808G30DBVR; SOT-23-6; JLCPCB C189211
U610, U611, U612, U613, U614, U615, U616, U617, U618: TS3A27518EPWR; TSSOP-24_4.4x7.8mm_P0.65mm; JLCPCB C443721
U700: TPSM63606RDLR; TI_TPSM63606_RDL0020A_EVM; Manufacturer_PN TPSM63606RDLR; JLCPCB C5219325
U701, U702, U703, U704, U705, U706, U707, U708: TPS2553DBVR; SOT-23-6; Manufacturer_PN TPS2553DBVR; JLCPCB C55266
U801, U802, U803, U804, U805, U806, U807, U808: TPD4E02B04DQAR; USON-10_2.5x1.0mm_P0.5mm; Manufacturer_PN TPD4E02B04DQAR; JLCPCB C106794
Y500: 7U12000E18UCG 12MHz; Y500; MPN 7U12000E18UCG; JLCPCB C524717

Connections (part):
+1.2V_DDR: MC3.80 (+1.2V_DDR), R2.2
+1.8V: C603.1, C605.1, MC1.2 (+1.8V), R629.2, TP711.1, U602.14 (VCCB_1V8)
+3.3V: C601.1, C606.1, C609.1, C610.1, C611.1, C612.1, C613.1, C614.1, C615.1, C616.1, C617.1, C618.1, MC2.70 (+3.3V), R30.2, R31.2, R615.1, R620.1, R621.1, R622.1, R623.1, R624.1, R625.1, R626.1, R627.1, R628.1, SW601.5 (ENABLE_3V3), TP712.1, U603.5 (VDD), U605.5 (SENSE), U605.6 (VDD), U610.8 (VCC_3V3), U610.14 (IN2_HIGH), U610.24 (IN1_HIGH), U611.8 (VCC_3V3), U611.14 (IN2_HIGH), U611.24 (IN1_HIGH), U612.8 (VCC_3V3), U612.14 (IN2_HIGH), U612.24 (IN1_HIGH), U613.8 (VCC_3V3), U613.14 (IN2_HIGH), U613.24 (IN1_HIGH), U614.8 (VCC_3V3), U614.14 (IN2_HIGH), U614.24 (IN1_HIGH), U615.8 (VCC_3V3), U615.14 (IN2_HIGH), U615.24 (IN1_HIGH), U616.8 (VCC_3V3), U616.14 (IN2_HIGH), U616.24 (IN1_HIGH), U617.8 (VCC_3V3), U617.14 (IN2_HIGH), U617.24 (IN1_HIGH), U618.8 (VCC_3V3), U618.14 (IN2_HIGH), U618.24 (IN1_HIGH)
+3.3VAUX_PCIE: C31.2, R13.2, R23.2, U5.6 (OUT)
+3.3VAUX_PCIE_C: C32.2, J6.B10 (3.3Vaux), R18.2, U5.1 (IN)
+3.3V_PCIE_C: C12.2, J6.A9 (+3.3V), J6.A10 (+3.3V), J6.B8 (+3.3V), U4.6 (Vccb)
+VDCIN: C5.1, C6.2, C700.1, C701.1, C702.1, C703.1, J4.1, MC2.1 (+VDCIN), MC2.2 (+VDCIN), MC2.3 (+VDCIN), MC2.4 (+VDCIN), TP710.1, U700.1 (VIN1), U700.14 (EN/SYNC), U700.16 (VIN2)
/+12V_PCIE_C: J6.A2 (+12V), J6.A3 (+12V), J6.B1 (+12V), J6.B2 (+12V), J6.B3 (+12V), TP20.1
/FTDI3V3_PHY: C515.1, C516.1, FB501.2, U501.3 (VPHY)
/FTDI3V3_PLL: C513.1, C514.1, FB500.2, U501.8 (VPLL)
/FTDI5V_FILTERED: C500.1, C501.1, FB502.2, U501.40 (VREGIN)
/FTDI_EECLK: R503.2, U501.44 (EECLK), U505.2 (CLK)
/FTDI_EECS: R502.1, U501.45 (EECS), U505.1 (CS)
/FTDI_EEDATA: R504.1, U501.43 (EEDATA), U505.3 (DI)
/PCIE_PERST_B_3V3: J6.A11 (PERST#), TP14.1, U4.4 (B)
/PCIE_PERST_B_VIO: R7.1, TP13.1, U4.3 (A)
/PCIE_PRSNT1_B: J6.A1 (PRSNT1#), R28.2
/PCIE_REFCLKN_C: C8.1, J6.A14 (REFCLK-)
/PCIE_REFCLKP_C: C7.1, J6.A13 (REFCLK+)
/PCIE_RX0N_C: C14.1, J6.A17 (PERn0)
/PCIE_RX0P_C: C13.1, J6.A16 (PERp0)
/PCIE_RX1N_C: C16.1, J6.A22 (PERn1)
/PCIE_RX1P_C: C15.1, J6.A21 (PERp1)
/PCIE_RX2N_C: C18.1, J6.A26 (PERn2)
/PCIE_RX2P_C: C17.1, J6.A25 (PERp2)
/PCIE_RX3N_C: C20.1, J6.A30 (PERn3)
/PCIE_RX3P_C: C19.1, J6.A29 (PERp3)
/PCIE_SMCLK_3V3: J6.B5 (SMCLK), TP11.1, U2.5 (SDA2)
/PCIE_SMCLK_VIO: R11.1, R14.1, TP12.1, U2.4 (SDA1)
/PCIE_SMDAT_3V3: J6.B6 (SMDAT), TP10.1, U2.6 (SCL2)
/PCIE_SMDAT_VIO: R10.1, R15.1, TP9.1, U2.3 (SCL1)
/PCIE_WAKE_B_3V3: J6.B11 (WAKE#), TP16.1, U6.6 (SCL2)
/PCIE_WAKE_B_VIO: R9.1, R25.1, TP15.1, U6.3 (SCL1)
/VIO_PG: Q1.3 (D2), R31.1, R32.2, U5.3 (EN)
B64_L1N: J610.14 (GPIO_N), MC1.12 (B64_L1N), U801.5 (IO4), U801.6 (IO4_FT)
B64_L1P: J610.12 (GPIO_P), MC1.10 (B64_L1P), U801.4 (IO3), U801.7 (IO3_FT)
B64_L2N: J611.14 (GPIO_N), MC1.16 (B64_L2N), U802.5 (IO4), U802.6 (IO4_FT)
B64_L2P: J611.12 (GPIO_P), MC1.14 (B64_L2P), U802.4 (IO3), U802.7 (IO3_FT)
B64_L3N: J612.14 (GPIO_N), MC1.15 (B64_L3N), U803.5 (IO4), U803.6 (IO4_FT)
B64_L3P: J612.12 (GPIO_P), MC1.13 (B64_L3P), U803.4 (IO3), U803.7 (IO3_FT)
B64_L4N: J613.14 (GPIO_N), MC1.8 (B64_L4N), U804.5 (IO4), U804.6 (IO4_FT)
B64_L4P: J613.12 (GPIO_P), MC1.6 (B64_L4P), U804.4 (IO3), U804.7 (IO3_FT)
B64_L5N: J614.14 (GPIO_N), MC1.7 (B64_L5N), U805.5 (IO4), U805.6 (IO4_FT)
B64_L5P: J614.12 (GPIO_P), MC1.5 (B64_L5P), U805.4 (IO3), U805.7 (IO3_FT)
B64_L6N: J615.14 (GPIO_N), MC1.11 (B64_L6N), U806.5 (IO4), U806.6 (IO4_FT)
B64_L6P: J615.12 (GPIO_P), MC1.9 (B64_L6P), U806.4 (IO3), U806.7 (IO3_FT)
B64_L7N: J616.14 (GPIO_N), MC1.23 (B64_L7N), U807.5 (IO4), U807.6 (IO4_FT)
B64_L7P: J616.12 (GPIO_P), MC1.21 (B64_L7P), U807.4 (IO3), U807.7 (IO3_FT)
B64_L8N: J617.14 (GPIO_N), MC1.20 (B64_L8N), U808.5 (IO4), U808.6 (IO4_FT)
B64_L8P: J617.12 (GPIO_P), MC1.18 (B64_L8P), U808.4 (IO3), U808.7 (IO3_FT)
B64_L9N: MC1.24 (B64_L9N)
B64_L9P: MC1.22 (B64_L9P)
B64_L10N: MC1.28 (B64_L10N)
B64_L10P: MC1.26 (B64_L10P)
B64_L11N_GC: MC1.39 (B64_L11N_GC)
B64_L11P_GC: MC1.37 (B64_L11P_GC)
B64_L12N_GC: MC1.43 (B64_L12N_GC)
B64_L12P_GC: MC1.41 (B64_L12P_GC)
B64_L13N_GC: MC1.27 (B64_L13N_GC)
B64_L13P_GC: MC1.25 (B64_L13P_GC)
B64_L14N_GC: MC1.47 (B64_L14N_GC)
B64_L14P_GC: MC1.45 (B64_L14P_GC)
B64_L15N: MC1.35 (B64_L15N)
B64_L15P: MC1.33 (B64_L15P)
B64_L16N: MC1.51 (B64_L16N)
B64_L16P: MC1.49 (B64_L16P)
B64_L17N: MC1.44 (B64_L17N), R11.2
B64_L17P: MC1.42 (B64_L17P), R10.2
B64_L18N: MC1.56 (B64_L18N)
B64_L18P: MC1.54 (B64_L18P)
B64_L19N: MC1.19 (B64_L19N)
B64_L19P: MC1.17 (B64_L19P)
B64_L20N: MC1.40 (B64_L20N), R9.2
B64_L20P: MC1.38 (B64_L20P)
B64_L21N: MC1.36 (B64_L21N)
B64_L21P: MC1.34 (B64_L21P)
B64_L22N: MC1.52 (B64_L22N)
B64_L22P: MC1.50 (B64_L22P)
B64_L23N: MC1.55 (B64_L23N)
B64_L23P: MC1.53 (B64_L23P)
B64_L24N: MC1.48 (B64_L24N)
B64_L24P: MC1.46 (B64_L24P)
B64_T0U_N12: MC1.32 (B64_T0U_N12)
B64_T1U_N12: MC1.31 (B64_T1U_N12)
B64_T2U_N12: MC1.57 (B64_T2U_N12)
B64_T3U_N12: MC1.58 (B64_T3U_N12)
B67_L13N_GC: MC3.71 (B67_L13N_GC)
B67_L13P_GC: MC3.69 (B67_L13P_GC)
B67_L14N_GC: MC3.60 (B67_L14N_GC)
B67_L14P_GC: MC3.58 (B67_L14P_GC)
B67_L15N: MC3.59 (B67_L15N)
B67_L15P: MC3.57 (B67_L15P)
B67_L16N: MC3.68 (B67_L16N)
B67_L16P: MC3.66 (B67_L16P)
B67_L17N: MC3.64 (B67_L17N)
B67_L17P: MC3.62 (B67_L17P)
B67_L18N: MC3.67 (B67_L18N)
B67_L18P: MC3.65 (B67_L18P)
B67_L19N: MC3.76 (B67_L19N)
B67_L19P: MC3.74 (B67_L19P)
B67_L20N: MC3.39 (B67_L20N)
B67_L20P: MC3.37 (B67_L20P)
B67_L21N: MC3.75 (B67_L21N)
B67_L21P: MC3.73 (B67_L21P)
B67_L22N: MC3.63 (B67_L22N)
B67_L22P: MC3.61 (B67_L22P)
B67_L23N: MC3.79 (B67_L23N)
B67_L23P: MC3.77 (B67_L23P)
B67_L24N: MC3.72 (B67_L24N)
B67_L24P: MC3.70 (B67_L24P)
B67_T3U_N12: MC3.78 (B67_T3U_N12), R7.2
B84_L1N: MC1.64 (B84_L1N)
B84_L1P: MC1.62 (B84_L1P)
B84_L2N: MC1.71 (B84_L2N)
B84_L2P: MC1.69 (B84_L2P)
B84_L3N: MC1.72 (B84_L3N)
B84_L3P: MC1.70 (B84_L3P)
B84_L4N: MC1.63 (B84_L4N)
B84_L4P: MC1.61 (B84_L4P)
B84_L5N_HDGC: MC1.76 (B84_L5N_HDGC)
B84_L5P_HDGC: MC1.74 (B84_L5P_HDGC)
B84_L6N_HDGC: MC1.67 (B84_L6N_HDGC)
B84_L6P_HDGC: MC1.65 (B84_L6P_HDGC)
B84_L7N_HDGC: MC2.62 (B84_L7N_HDGC)
B84_L7P_HDGC: MC2.60 (B84_L7P_HDGC)
B84_L8N_HDGC: MC1.75 (B84_L8N_HDGC)
B84_L8P_HDGC: MC1.73 (B84_L8P_HDGC)
B84_L9N: MC1.68 (B84_L9N)
B84_L9P: MC1.66 (B84_L9P)
B84_L10N: MC2.61 (B84_L10N)
B84_L10P: MC2.59 (B84_L10P)
B84_L11N: MC2.66 (B84_L11N)
B84_L11P: MC2.64 (B84_L11P)
B84_L12N: MC2.65 (B84_L12N)
B84_L12P: MC2.63 (B84_L12P)
B86_L1N: MC2.57 (B86_L1N)
B86_L1P: MC2.55 (B86_L1P)
B86_L2N: MC2.50 (B86_L2N)
B86_L2P: MC2.48 (B86_L2P)
B86_L3N: MC2.49 (B86_L3N)
B86_L3P: MC2.47 (B86_L3P)
B86_L4N: MC2.45 (B86_L4N)
B86_L4P: MC2.43 (B86_L4P)
B86_L5N_HDGC: MC2.58 (B86_L5N_HDGC)
B86_L5P_HDGC: MC2.56 (B86_L5P_HDGC)
B86_L6N_HDGC: MC2.54 (B86_L6N_HDGC)
B86_L6P_HDGC: MC2.52 (B86_L6P_HDGC)
B86_L7N_HDGC: MC2.42 (B86_L7N_HDGC)
B86_L7P_HDGC: MC2.40 (B86_L7P_HDGC)
B86_L8N_HDGC: MC2.41 (B86_L8N_HDGC)
B86_L8P_HDGC: MC2.39 (B86_L8P_HDGC)
B86_L9N: MC2.53 (B86_L9N)
B86_L9P: MC2.51 (B86_L9P)
B86_L10N: MC2.46 (B86_L10N)
B86_L10P: MC2.44 (B86_L10P)
B86_L11N: MC2.38 (B86_L11N)
B86_L11P: MC2.36 (B86_L11P)
B86_L12N: MC2.37 (B86_L12N)
B86_L12P: MC2.35 (B86_L12P)
B87_L1N: MC2.32 (B87_L1N)
B87_L1P: MC2.30 (B87_L1P)
B87_L2N: MC2.12 (B87_L2N)
B87_L2P: MC2.10 (B87_L2P)
B87_L3N: MC2.16 (B87_L3N)
B87_L3P: MC2.14 (B87_L3P)
B87_L4N: MC2.11 (B87_L4N)
B87_L4P: MC2.9 (B87_L4P)
B87_L5N_HDGC: MC2.31 (B87_L5N_HDGC)
B87_L5P_HDGC: MC2.29 (B87_L5P_HDGC)
B87_L6N_HDGC: MC2.19 (B87_L6N_HDGC)
B87_L6P_HDGC: MC2.17 (B87_L6P_HDGC)
B87_L7N_HDGC: MC2.27 (B87_L7N_HDGC)
B87_L7P_HDGC: MC2.25 (B87_L7P_HDGC)
B87_L8N_HDGC: MC2.24 (B87_L8N_HDGC)
B87_L8P_HDGC: MC2.22 (B87_L8P_HDGC)
B87_L9N: MC2.20 (B87_L9N)
B87_L9P: MC2.18 (B87_L9P)
B87_L10N: MC2.23 (B87_L10N)
B87_L10P: MC2.21 (B87_L10P)
B87_L11N: MC2.28 (B87_L11N)
B87_L11P: MC2.26 (B87_L11P)
B87_L12N: MC2.15 (B87_L12N)
B87_L12P: MC2.13 (B87_L12P)
DGND: C5.2, C6.1, C9.1, C10.1, C11.1, C12.1, C27.1, C28.1, C31.1, C32.1, C500.2, C501.2, C502.2, C503.2, C504.2, C505.2, C506.1, C507.2, C508.2, C509.2, C510.2, C511.2, C512.2, C513.2, C514.2, C515.2, C516.2, C517.1, C518.1, C519.2, C601.2, C603.2, C604.2, C605.2, C606.2, C608.2, C609.2, C610.2, C611.2, C612.2, C613.2, C614.2, C615.2, C616.2, C617.2, C618.2, C700.2, C701.2, C702.2, C703.2, C704.2, C705.2, C706.2, C707.2, C711.2, C712.2, C713.2, C714.2, C715.2, C716.2, C717.2, C718.2, D500.2 (GND), FB503.1, J4.2, J6.A4 (GND), J6.A12 (GND), J6.A15 (GND), J6.A18 (GND), J6.A20 (GND), J6.A23 (GND), J6.A24 (GND), J6.A27 (GND), J6.A28 (GND), J6.A31 (GND), J6.A34 (GND), J6.A37 (GND), J6.A38 (GND), J6.A41 (GND), J6.A42 (GND)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
DRIVE_ENABLE: R615.2, R616.1, U602.8 (OE), U605.1 (RESET_N)
FE_5V: C704.1, C705.1, C706.1, C707.1, C708.1, C711.1, C712.1, C713.1, C714.1, C715.1, C716.1, C717.1, C718.1, R700.2, R703.2, R721.2, R722.2, R723.2, R724.2, R725.2, R726.2, R727.2, R728.2, TP700.1, U700.5 (VLDOIN), U700.8 (VOUT1), U700.9 (VOUT2), U701.1 (IN), U702.1 (IN), U703.1 (IN), U704.1 (IN), U705.1 (IN), U706.1 (IN), U707.1 (IN), U708.1 (IN)
FTDI3V3: C505.1, C507.1, C508.1, C509.1, C510.1, C511.1, C512.1, C604.1, FB500.1, FB501.1, R503.1, R505.2, R506.1, R509.2, TP713.1, U501.12 (VCCIO), U501.24 (VCCIO), U501.39 (VCCD), U501.46 (VCCIO), U505.8 (VCC), U602.1 (VCCA_3V3)
GNDADC: MC2.77 (GNDADC)
HDMI1_JTAG_TCK: J610.17 (TCK), R640.2
HDMI1_JTAG_TDI: J610.15 (TDI), R641.2
HDMI1_JTAG_TDO: J610.18 (TDO), R643.2
HDMI1_JTAG_TMS: J610.2 (TMS), R642.2
HDMI1_TX1_FUTURE_N_PENDING: J610.8 (TX1_N)
HDMI1_TX1_FUTURE_P_PENDING: J610.6 (TX1_P)
HDMI1_TX2_FUTURE_N_PENDING: J610.11 (TX2_N)
HDMI1_TX2_FUTURE_P_PENDING: J610.9 (TX2_P)
HDMI1_VREF: J610.1 (VREF), U611.13 (NO2)
HDMI2_JTAG_TCK: J611.17 (TCK), R644.2
HDMI2_JTAG_TDI: J611.15 (TDI), R645.2
HDMI2_JTAG_TDO: J611.18 (TDO), R647.2
HDMI2_JTAG_TMS: J611.2 (TMS), R646.2
HDMI2_TX1_FUTURE_N_PENDING: J611.8 (TX1_N)
HDMI2_TX1_FUTURE_P_PENDING: J611.6 (TX1_P)
HDMI2_TX2_FUTURE_N_PENDING: J611.11 (TX2_N)
HDMI2_TX2_FUTURE_P_PENDING: J611.9 (TX2_P)
HDMI2_VREF: J611.1 (VREF), U612.13 (NO2)
HDMI3_JTAG_TCK: J612.17 (TCK), R648.2
HDMI3_JTAG_TDI: J612.15 (TDI), R649.2
HDMI3_JTAG_TDO: J612.18 (TDO), R651.2
HDMI3_JTAG_TMS: J612.2 (TMS), R650.2
HDMI3_TX1_FUTURE_N_PENDING: J612.8 (TX1_N)
HDMI3_TX1_FUTURE_P_PENDING: J612.6 (TX1_P)
HDMI3_TX2_FUTURE_N_PENDING: J612.11 (TX2_N)
HDMI3_TX2_FUTURE_P_PENDING: J612.9 (TX2_P)
HDMI3_VREF: J612.1 (VREF), U613.13 (NO2)
HDMI4_JTAG_TCK: J613.17 (TCK), R652.2
HDMI4_JTAG_TDI: J613.15 (TDI), R653.2
HDMI4_JTAG_TDO: J613.18 (TDO), R655.2
HDMI4_JTAG_TMS: J613.2 (TMS), R654.2
HDMI4_TX1_FUTURE_N_PENDING: J613.8 (TX1_N)
HDMI4_TX1_FUTURE_P_PENDING: J613.6 (TX1_P)
HDMI4_TX2_FUTURE_N_PENDING: J613.11 (TX2_N)
HDMI4_TX2_FUTURE_P_PENDING: J613.9 (TX2_P)
HDMI4_VREF: J613.1 (VREF), U614.13 (NO2)
HDMI5_JTAG_TCK: J614.17 (TCK), R656.2
HDMI5_JTAG_TDI: J614.15 (TDI), R657.2
HDMI5_JTAG_TDO: J614.18 (TDO), R659.2
HDMI5_JTAG_TMS: J614.2 (TMS), R658.2
HDMI5_TX1_FUTURE_N_PENDING: J614.8 (TX1_N)
HDMI5_TX1_FUTURE_P_PENDING: J614.6 (TX1_P)
HDMI5_TX2_FUTURE_N_PENDING: J614.11 (TX2_N)
HDMI5_TX2_FUTURE_P_PENDING: J614.9 (TX2_P)
HDMI5_VREF: J614.1 (VREF), U615.13 (NO2)
HDMI6_JTAG_TCK: J615.17 (TCK), R660.2
HDMI6_JTAG_TDI: J615.15 (TDI), R661.2
HDMI6_JTAG_TDO: J615.18 (TDO), R663.2
HDMI6_JTAG_TMS: J615.2 (TMS), R662.2
HDMI6_TX1_FUTURE_N_PENDING: J615.8 (TX1_N)
HDMI6_TX1_FUTURE_P_PENDING: J615.6 (TX1_P)
HDMI6_TX2_FUTURE_N_PENDING: J615.11 (TX2_N)
HDMI6_TX2_FUTURE_P_PENDING: J615.9 (TX2_P)
HDMI6_VREF: J615.1 (VREF), U616.13 (NO2)
HDMI7_JTAG_TCK: J616.17 (TCK), R664.2
HDMI7_JTAG_TDI: J616.15 (TDI), R665.2
HDMI7_JTAG_TDO: J616.18 (TDO), R667.2
HDMI7_JTAG_TMS: J616.2 (TMS), R666.2
HDMI7_TX1_FUTURE_N_PENDING: J616.8 (TX1_N)
HDMI7_TX1_FUTURE_P_PENDING: J616.6 (TX1_P)
HDMI7_TX2_FUTURE_N_PENDING: J616.11 (TX2_N)
HDMI7_TX2_FUTURE_P_PENDING: J616.9 (TX2_P)
HDMI7_VREF: J616.1 (VREF), U617.13 (NO2)
HDMI8_JTAG_TCK: J617.17 (TCK), R668.2
HDMI8_JTAG_TDI: J617.15 (TDI), R669.2
HDMI8_JTAG_TDO: J617.18 (TDO), R671.2
HDMI8_JTAG_TMS: J617.2 (TMS), R670.2
HDMI8_TX1_FUTURE_N_PENDING: J617.8 (TX1_N)
HDMI8_TX1_FUTURE_P_PENDING: J617.6 (TX1_P)
HDMI8_TX2_FUTURE_N_PENDING: J617.11 (TX2_N)
HDMI8_TX2_FUTURE_P_PENDING: J617.9 (TX2_P)
HDMI8_VREF: J617.1 (VREF), U618.13 (NO2)
HOST_TCK: U501.13 (ADBUS0_/_TCK_/_SK), U602.2 (A1_TCK)
HOST_TDI: U501.14 (ADBUS1_/_TDI_/_DO), U602.3 (A2_TDI)
HOST_TDO: R509.1, U501.15 (ADBUS2_/_TDO_/_DI), U602.5 (A4Y_TDO)
HOST_TMS: U501.16 (ADBUS3_/_TMS_/_CS), U602.4 (A3_TMS)
JTAG_TCK: MC2.76 (JTAG_TCK), U610.17 (NO4)
JTAG_TCK_1V8: R601.2, U610.9 (COM4), U611.9 (COM4), U612.9 (COM4), U613.9 (COM4), U614.9 (COM4), U615.9 (COM4), U616.9 (COM4), U617.9 (COM4), U618.9 (COM4)
JTAG_TDI: MC2.74 (JTAG_TDI), U610.16 (NO6)
JTAG_TDI_1V8: R602.2, U610.12 (COM6), U611.12 (COM6), U612.12 (COM6), U613.12 (COM6), U614.12 (COM6), U615.12 (COM6), U616.12 (COM6), U617.12 (COM6), U618.12 (COM6)
JTAG_TDO: MC2.71 (JTAG_TDO), U610.18 (NO5)
JTAG_TDO_1V8: U602.10 (B4_TDO), U610.10 (COM5), U611.10 (COM5), U612.10 (COM5), U613.10 (COM5), U614.10 (COM5), U615.10 (COM5), U616.10 (COM5), U617.10 (COM5), U618.10 (COM5)
JTAG_TMS: MC2.72 (JTAG_TMS), U610.15 (NO3)
JTAG_TMS_1V8: R603.2, U610.7 (COM3), U611.7 (COM3), U612.7 (COM3), U613.7 (COM3), U614.7 (COM3), U615.7 (COM3), U616.7 (COM3), U617.7 (COM3), U618.7 (COM3)
MASTER: R600.1, R614.1, SW601.6 (MASTER)
MGT_REFCLK0N_224_C: MC3.20 (MGT_REFCLK0N_224_C)
MGT_REFCLK0N_226_C: MC3.40 (MGT_REFCLK0N_226_C)
MGT_REFCLK0P_224_C: MC3.18 (MGT_REFCLK0P_224_C)
MGT_REFCLK0P_226_C: MC3.38 (MGT_REFCLK0P_226_C)
MGT_REFCLK1N_225_C: C8.2, MC3.19 (MGT_REFCLK1N_225_C)
MGT_REFCLK1P_225_C: C7.2, MC3.17 (MGT_REFCLK1P_225_C)
MGT_RXN0_224: J610.5 (TX0_N), MC3.3 (MGT_RXN0_224), U801.2 (IO2), U801.9 (IO2_FT)
MGT_RXN0_225: J6.B28 (PETn3), MC3.23 (MGT_RXN0_225)
MGT_RXN0_226: J614.5 (TX0_N), MC3.43 (MGT_RXN0_226), U805.2 (IO2), U805.9 (IO2_FT)
MGT_RXN1_224: J611.5 (TX0_N), MC3.7 (MGT_RXN1_224), U802.2 (IO2), U802.9 (IO2_FT)
MGT_RXN1_225: J6.B24 (PETn2), MC3.27 (MGT_RXN1_225)
MGT_RXN1_226: J615.5 (TX0_N), MC3.47 (MGT_RXN1_226), U806.2 (IO2), U806.9 (IO2_FT)
MGT_RXN2_224: J612.5 (TX0_N), MC3.11 (MGT_RXN2_224), U803.2 (IO2), U803.9 (IO2_FT)
MGT_RXN2_225: J6.B20 (PETn1), MC3.31 (MGT_RXN2_225)
MGT_RXN2_226: J616.5 (TX0_N), MC3.51 (MGT_RXN2_226), U807.2 (IO2), U807.9 (IO2_FT)
MGT_RXN3_224: J613.5 (TX0_N), MC3.15 (MGT_RXN3_224), U804.2 (IO2), U804.9 (IO2_FT)
MGT_RXN3_225: J6.B15 (PETn0), MC3.35 (MGT_RXN3_225)
MGT_RXN3_226: J617.5 (TX0_N), MC3.55 (MGT_RXN3_226), U808.2 (IO2), U808.9 (IO2_FT)
MGT_RXP0_224: J610.3 (TX0_P), MC3.1 (MGT_RXP0_224), U801.1 (IO1), U801.10 (IO1_FT)
MGT_RXP0_225: J6.B27 (PETp3), MC3.21 (MGT_RXP0_225)
MGT_RXP0_226: J614.3 (TX0_P), MC3.41 (MGT_RXP0_226), U805.1 (IO1), U805.10 (IO1_FT)
MGT_RXP1_224: J611.3 (TX0_P), MC3.5 (MGT_RXP1_224), U802.1 (IO1), U802.10 (IO1_FT)
MGT_RXP1_225: J6.B23 (PETp2), MC3.25 (MGT_RXP1_225)
MGT_RXP1_226: J615.3 (TX0_P), MC3.45 (MGT_RXP1_226), U806.1 (IO1), U806.10 (IO1_FT)
MGT_RXP2_224: J612.3 (TX0_P), MC3.9 (MGT_RXP2_224), U803.1 (IO1), U803.10 (IO1_FT)
MGT_RXP2_225: J6.B19 (PETp1), MC3.29 (MGT_RXP2_225)
MGT_RXP2_226: J616.3 (TX0_P), MC3.49 (MGT_RXP2_226), U807.1 (IO1), U807.10 (IO1_FT)
MGT_RXP3_224: J613.3 (TX0_P), MC3.13 (MGT_RXP3_224), U804.1 (IO1), U804.10 (IO1_FT)
MGT_RXP3_225: J6.B14 (PETp0), MC3.33 (MGT_RXP3_225)
MGT_RXP3_226: J617.3 (TX0_P), MC3.53 (MGT_RXP3_226), U808.1 (IO1), U808.10 (IO1_FT)
MGT_TXN0_224: MC3.4 (MGT_TXN0_224)
MGT_TXN0_225: C20.2, MC3.24 (MGT_TXN0_225)
MGT_TXN0_226: MC3.44 (MGT_TXN0_226)
MGT_TXN1_224: MC3.8 (MGT_TXN1_224)
MGT_TXN1_225: C18.2, MC3.28 (MGT_TXN1_225)
MGT_TXN1_226: MC3.48 (MGT_TXN1_226)
MGT_TXN2_224: MC3.12 (MGT_TXN2_224)
MGT_TXN2_225: C16.2, MC3.32 (MGT_TXN2_225)
MGT_TXN2_226: MC3.52 (MGT_TXN2_226)
MGT_TXN3_224: MC3.16 (MGT_TXN3_224)
MGT_TXN3_225: C14.2, MC3.36 (MGT_TXN3_225)
MGT_TXN3_226: MC3.56 (MGT_TXN3_226)
MGT_TXP0_224: MC3.2 (MGT_TXP0_224)
MGT_TXP0_225: C19.2, MC3.22 (MGT_TXP0_225)
MGT_TXP0_226: MC3.42 (MGT_TXP0_226)
MGT_TXP1_224: MC3.6 (MGT_TXP1_224)
MGT_TXP1_225: C17.2, MC3.26 (MGT_TXP1_225)
MGT_TXP1_226: MC3.46 (MGT_TXP1_226)
MGT_TXP2_224: MC3.10 (MGT_TXP2_224)
MGT_TXP2_225: C15.2, MC3.30 (MGT_TXP2_225)
MGT_TXP2_226: MC3.50 (MGT_TXP2_226)
MGT_TXP3_224: MC3.14 (MGT_TXP3_224)
MGT_TXP3_225: C13.2, MC3.34 (MGT_TXP3_225)
MGT_TXP3_226: MC3.54 (MGT_TXP3_226)
unnamed: C502.1, FB503.2, J500.M1 (SHELL), J500.M2 (SHELL), J500.M3 (SHELL), J500.M4 (SHELL)
unnamed: D701.2 (A), R721.1
unnamed: D701.1 (K), U701.4 (FAULT)
unnamed: D702.2 (A), R722.1
unnamed: D702.1 (K), U702.4 (FAULT)
unnamed: D703.2 (A), R723.1
unnamed: D703.1 (K), U703.4 (FAULT)
unnamed: D704.2 (A), R724.1
unnamed: D704.1 (K), U704.4 (FAULT)
unnamed: D705.2 (A), R725.1
unnamed: D705.1 (K), U705.4 (FAULT)
unnamed: D706.2 (A), R726.1
unnamed: D706.1 (K), U706.4 (FAULT)
unnamed: D707.2 (A), R727.1
unnamed: D707.1 (K), U707.4 (FAULT)
unnamed: D708.2 (A), R728.1
unnamed: D708.1 (K), U708.4 (FAULT)
unnamed: J6.B31 (PRSNT2#), R28.1
unnamed: J500.A5 (CC1), R500.2
unnamed: J500.B5 (CC2), R501.1
unnamed: Q1.5 (G2), Q1.6 (D1), R30.1
unnamed: R18.1, TP21.1, U5.4 (~FAULT)
unnamed: C10.2, R13.1, U2.7 (VREF2), U2.8 (EN)
unnamed: C11.2, R2.1, U4.1 (Vcca)
unnamed: R24.2, U5.5 (ILIM)
unnamed: C28.2, R23.1, U6.7 (VREF2), U6.8 (EN)
unnamed: C503.1, U501.1 (OSCI), Y500.1 (OSC1)
unnamed: C504.1, U501.2 (OSCO), Y500.3 (OSC2)
unnamed: R507.1, U501.5 (REF)
unnamed: C518.2, U501.37 (VCCA)
unnamed: C517.2, U501.38 (VCORE)
unnamed: C519.1, R506.2, U501.34 (~RESET)
unnamed: R504.2, R505.1, U505.4 (DO)
unnamed: R601.1, U602.13 (B1Y_TCK)
unnamed: R602.1, U602.12 (B2Y_TDI)
unnamed: R603.1, U602.11 (B3Y_TMS)
unnamed: R605.2, R606.2, U603.3 (INA+)
unnamed: R607.2, R608.2, U603.4 (INB-)
unnamed: R629.1, U610.13 (NO2)
unnamed: R642.1, U611.15 (NO3)
unnamed: R640.1, U611.17 (NO4)
unnamed: R643.1, U611.18 (NO5)
unnamed: R641.1, U611.16 (NO6)
unnamed: R646.1, U612.15 (NO3)
unnamed: R644.1, U612.17 (NO4)
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
Notes on the sheet:
Function: HDMI6 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
Function: HDMI5 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
Function: HDMI 5 carries recording, command, JTAG, sense and 5 V. U805 helps shunt data-line ESD; shell is bonded to DGND.
Function: HDMI1 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J611 3/5 to MGT_RX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
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J616 3/5 to MGT_RX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
Function: HDMI 3 carries recording, command, JTAG, sense and 5 V. U803 helps shunt data-line ESD; shell is bonded to DGND.
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J617 3/5 to MGT_RX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
USB-C JTAG PROGRAMMER, SELECTION AND FRONTEND PORTS
Function: U700 converts +VDCIN to FE_5V (5.02 V nominal, 6 A module rating). PG and R703 enable all eight ports once the central rail is in regulation. Source / changes: TI TPSM63606 SLVSGB4B Rev. B, Fig. 9-1 and Table 8-1, https://www.ti.com/lit/ds/symlink/tpsm63606.pdf . Codex adapted prior V14 U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
Source / changes: Codex circuit using TI TS3A27518E Rev F Fig.5-2, Table 8-1: https://www.ti.com/lit/ds/symlink/ts3a27518e.pdf IN1/IN2 high select NO; active-low EN from rotary; 10k pullup. Channels (Howard 1 Nov 2026, for straight PCB routing): TCK=4, TDI=6, TMS=3, TDO=5, VREF=2; channel 1 unused.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
USB TO JTAG PROGRAMMER
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J612 3/5 to MGT_RX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
XEM8310 MODULE MOUNTING HOLES
Function: HDMI 7 carries recording, command, JTAG, sense and 5 V. U807 helps shunt data-line ESD; shell is bonded to DGND.
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J610 3/5 to MGT_RX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
Function: U701-U708 individually switch FE_5V to J610-J617 pin 19; red LEDs indicate each switch FAULT. TP701-TP708 access the outputs. All ports start together; no staggering. Source / changes: TI TPS2553 SLVS841G Rev. G, pins / sections 8-9 and Table 9-2: https://www.ti.com/lit/ds/symlink/tps2553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
Function: HDMI2 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J613 3/5 to MGT_RX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
Function: HDMI8 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
FRONTEND 5 V POWER | CUSTOM MICRO-HDMI PORTS - NOT STANDARD HDMI
Function: HDMI 8 carries recording, command, JTAG, sense and 5 V. U808 helps shunt data-line ESD; shell is bonded to DGND.
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J614 3/5 to MGT_RX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
Function: HDMI 6 carries recording, command, JTAG, sense and 5 V. U806 helps shunt data-line ESD; shell is bonded to DGND.
Function: HDMI4 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
Function: HDMI 4 carries recording, command, JTAG, sense and 5 V. U804 helps shunt data-line ESD; shell is bonded to DGND.
Function: HDMI3 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
Function: HDMI 1 carries recording, command, JTAG, sense and 5 V. U801 helps shunt data-line ESD; shell is bonded to DGND.
Function: HDMI7 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
HDMI EXTENSION BOARD - XEM8310 CONNECTIONS, POWER AND MOUNTING
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J615 3/5 to MGT_RX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
Power Jack
12 V nominal, center positive
Function: HDMI 2 carries recording, command, JTAG, sense and 5 V. U802 helps shunt data-line ESD; shell is bonded to DGND.
PCIe x4 — BRK8310 reference circuit
Function: Connects PCIe x4 data and 100 MHz reference clock, with reset, SMBus and WAKE#. Host slot 12 V is isolated from the board 12 V input.
Source / changes: Opal Kelly BRK8310-A01 schematic, p. 2, 2022-05-19: https://pins.opalkelly.com/downloads/442/download?category_id=3 Adapted from x8 to x4: fit R28 = 0 ohm; omit R29 and unused lanes 4–7 and C21–C26/C29–C30. R2/R7 and R9–R11 retained. Unused options R1/R8, R16/R17 and R27 are omitt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
Function: XEM8310 connectors provide the board power, FPGA I/O, JTAG and GT connections; J4 is the 12 V input and MH1-MH4 mount the module.
Source / changes: Opal Kelly BRK8310-A01 p.1 (2022-05-19): https://pins.opalkelly.com/downloads/442/download?category_id=3 ; Codex assigned the custom HDMI and x4 nets. VIO1 target is 1.5 V; program and verify it.
FRONTEND PORT 1 | JTAG SWITCH + MICRO-HDMI
